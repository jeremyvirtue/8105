# Keil uVision project LX8SF16P24.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA NXP
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODP2
  output: MI-103-FS-V1.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\User\Drive
  link misc: REMOVEUNUSED
  group User
    ./User/: main.c System.c Lcd.c OS.c KeyBoard.c kt_0646m.c UHF.c LcdDis.c
  group Drive
    ./User/Drive/: RCC.c Flash.c ADC.c
